require ${@bb.utils.contains('AGL_FEATURES', 'aglcore', 'weston_12.0_aglcore.inc', '', d)}
