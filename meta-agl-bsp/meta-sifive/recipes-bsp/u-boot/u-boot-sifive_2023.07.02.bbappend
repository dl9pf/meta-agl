FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-WIP-Make-BSP-work-under-YP-kirkstone.patch "
