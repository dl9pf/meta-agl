FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-fdtoverlay-Prevent-overlays-from-modifying-phandle-p.patch"
