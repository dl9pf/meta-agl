require checksum_control.inc

RDEPENDS:${PN}:append = " wayland-wsegl"
